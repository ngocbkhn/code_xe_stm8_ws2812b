# IAR project CLK_INTERNAL.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: C:\Users\ngocvm2\Desktop\CODE_XE\lib\inc; C:\Users\ngocvm2\Desktop\CODE_XE\user
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: CLK_INTERNAL.s19
  ILINK.IlinkOutputFile: CLK_INTERNAL.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_uart1.c WS2812B.c
  group user
    ./: effect.c effect.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h
